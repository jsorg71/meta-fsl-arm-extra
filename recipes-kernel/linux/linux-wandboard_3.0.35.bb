# adapted from linux-imx.inc, copyright (C) 2012-2013 O.S. Systems Software LTDA
# Released under the MIT license (see COPYING.MIT for the terms)

include linux-wandboard.inc

# Wandboard branch
SRCREV = "c504dd568455ef72e44fb1ee635d645cae74d04e"
LOCALVERSION = "-wandboard+yocto"

COMPATIBLE_MACHINE = "(wandboard)"
